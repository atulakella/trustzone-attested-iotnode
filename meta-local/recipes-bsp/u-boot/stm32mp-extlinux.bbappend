UBOOT_EXTLINUX_KERNEL_ARGS:append = " rauc.slot=${raucslot}"
UBOOT_EXTLINUX_ROOT:target-sdcard = "root=${rauc_root}"
